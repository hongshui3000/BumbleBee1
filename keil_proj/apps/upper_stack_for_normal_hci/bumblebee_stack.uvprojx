# Keil uVision project bumblebee_stack.uvprojx, settings and files
target upper (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: btstack +hex (library)
  AfterMake: cmd.exe /c .\copy_to_sdk.bat
  c flags: Optim=3 uC99=1
  c define: SRP1300,SPPDEMO
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\sdk\inc\os\freertos;..\..\..\sdk\src\stollmann\system\srp\startup;..\..\..\sdk\src\stollmann\system\rtos\FreeRTOSV7.5.2\Source\portable\RVDS\ARM_CM3;..\..\..\os\osif\inc;..\..\..\platform\inc;..\..\..\patch\inc;..\..\..\stack\upper\inc;..\..\..\stack\upper\src\bt\blueapi;..\..\..\stack\upper\src\bt\btcore
  asm include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT5: ROM 0x8002000 size 0x7e000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group stack
    ../../../stack/upper/src/trace/: cycle_queue.c trace_binary.c upper_stack_dump_api.c
    ../../../stack/upper/src/bt/blueapi/: blueapi_base.c blueapi_bface.c blueapi_cmd.c blueapi_link.c blueapi_osif.c blueapi_sec.c blueapi_store.c blueapi_util.c
    ../../../stack/upper/src/bt/btcore/: att.c blueapi.c blueapi_api.c bt_api.c btglib.c btman.c btsend.c btsm.c btsm_br.c btsm_le.c btsm_smp.c btsmmsg.c btsmutil.c btsmutil_le.c efuse_config.c gatt.c gatt_br.c gatt_le.c gatt_ll.c gattmsg.c gattproc.c gattutil.c hci.c hci_br.c hci_le.c hci_llif.c hciutil.c l2c.c l2c_br.c l2c_extf.c l2c_le.c l2cchman.c sdp.c sdp_db.c sdplib.c swtimer.c upper_stack_global.c
    ../../../sdk/src/stollmann/: diag.c
  group osif
    ../../../os/osif/: os.c
    ../../../os/osif/src/: os_intr.c os_mem.c os_message.c os_pool.c os_queue.c os_sched.c os_timer.c
  group platform
    ../../../platform/src/: crc16btx.c
