# Keil uVision project BB3_test_upperstack.uvprojx, settings and files
target BB3_test_upperstack (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ROM +hex
  BeforeMake: uuid.exe ..\symboltable_uuid.h
  BeforeMake: cmd.exe /C del /F ..\symboltable.lib
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --gnu --preinclude keil_lowerstack_defines.h --bss_threshold=0
  c include: ..\..\..\os\freertos\inc;..\..\..\patch\inc;..\..\..\platform\cmsis\cm4;..\..\..\platform\cmsis\rtl876x\include;..\..\..\platform\inc;..\..\..\platform\inc_internal;..\..\..\peripheral\inc;.\;..\..\..\stack\upper\inc;..\..\..\stack\upper\src\bt\btcore;..\..\..\stack\upper\src\bt\blueapi;..\..\..\os\osif\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\BB3.sct
  link misc: --diag_suppress=L6314 --symdefs=..\symboltable.lib --edit .\steering.txt  --datacompressor off
  group CMSIS
    ../../../platform/cmsis/rtl876x/src/arm/: startup_rtl8763.s
    ../../../platform/cmsis/rtl876x/src/: system_rtl8763.c
  group platform
    ../../../platform/src/: crc16btx.c main_full.c pingpong_buffer.c rtl_delay.c trace.c
  group os
    ../../../os/freertos/src/: croutine.c list.c queue.c tasks.c timers.c
    ../../../os/freertos/src/portable/Keil/ARM_CM4F/: port.c
    ../../../os/freertos/src/portable/MemMang/: heap_4.c
  group peripheral
    ../../../peripheral/src/: rtl876x_gdma.c rtl876x_uart.c
  group app
    ../../../apps/test/test_upper_stack/: app_queue.c blueapi_lib.c main.c test_cmd.c test_transport_uart.c test_upperstack_api.c test_upperstack_apisec.c test_upperstack_cmd.c test_upperstack_FreeRTOS.c test_upperstack_glc.c test_upperstack_glcp.c test_upperstack_utl.c
  group patch
    ../../../patch/src/: patch_framework.c patch_iodriver.c patch_lowerstack.c patch_upperstack.c
  group upper_stack
    ../../../stack/upper/src/trace/: cycle_queue.c trace_binary.c upper_stack_dump_api.c
    ../../../stack/upper/src/bt/blueapi/: blueapi_base.c blueapi_bface.c blueapi_cmd.c blueapi_link.c blueapi_osif.c blueapi_sec.c blueapi_store.c blueapi_tgt.c blueapi_util.c
    ../../../stack/upper/src/bt/btcore/: att.c blueapi.c blueapi_api.c bt_api.c btglib.c btman.c btsend.c btsm.c btsm_br.c btsm_le.c btsm_smp.c btsmmsg.c btsmutil.c btsmutil_le.c efuse_config.c gatt.c gatt_br.c gatt_le.c gatt_ll.c gattmsg.c gattproc.c gattutil.c hci.c hci_br.c hci_le.c hci_llif.c hciutil.c l2c.c l2c_br.c l2c_extf.c l2c_le.c l2cchman.c sdp.c sdp_db.c sdplib.c swtimer.c upper_stack_global.c
  group osif
    ../../../os/osif/: os.c
    ../../../os/osif/src/: os_intr.c os_mem.c os_message.c os_pool.c os_queue.c os_sched.c os_timer.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:DSP 1.4.6
