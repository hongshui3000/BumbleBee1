# Keil uVision project BB3_lowstack.uvprojx, settings and files
target BB3 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ROM +hex
  BeforeMake: uuid.exe ..\symboltable_uuid.h
  BeforeMake: cmd.exe /C del /F ..\symboltable.lib
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --gnu --preinclude lowerstack_defines.h --bss_threshold=0 --diag_suppress=1295
  c include: ..\..\os\freertos\inc;..\..\os\freertos\src\portable\MemMang;..\..\os\osif\inc;..\..\patch\inc;..\..\platform\cmsis\cm4;..\..\platform\cmsis\rtl876x\include;..\..\platform\inc;..\..\platform\inc_internal;..\..\peripheral\inc;..\..\stack\low\utils\logger\include;..\..\stack\low\platform_al\include;..\..\stack\low\platform;..\..\stack\low\os_al\include;..\..\stack\low\os\mint_os\include;..\..\stack\low\config;..\..\stack\low\btcontroller\export;..\..\stack\low\btcontroller\core\include;..\..\stack\low\btcontroller\core\hci\include;..\..\stack\low\btcontroller\core\hci_td\include;..\..\stack\low\btcontroller\core\baseband\include;..\..\stack\low\btcontroller\core\lc\include;..\..\stack\low\btcontroller\core\lmp\include;..\..\stack\low\btcontroller\core\auth;..\..\stack\low\btcontroller\core\utils;..\..\stack\low\utils\crypto;..\..\stack\low\utils\debug;..\..\stack\low\btcontroller\vendor\hci\include;..\..\stack\low\btcontroller\vendor\lmp\include;..\..\stack\low\btcontroller\vendor\pta\include;..\..\stack\low\btcontroller\vendor\plc\include;..\..\stack\low\btcontroller\vendor\fm\include;..\..\stack\low\btcontroller\vendor\tv\include;..\..\stack\low\btcontroller\core\ll\include;..\..\stack\low\btcontroller\core\bt_3dd\include;..\..\stack\low\btcontroller\core\secure_conn\include;..\..\stack\low\btcontroller\core\mws\include;..\..\stack\low\btcontroller\core\phy_init\include;..\..\stack\low\platform\S3C2410\export;..\..\stack\low\platform\S3C2410\include;..\..\stack\low\platform\S3C2410\4181\include;..\..\stack\low\platform\S3C2410\baseband\include;..\..\stack\low\platform\S3C2410\gpio\include;..\..\stack\low\platform\S3C2410\otp\include;..\..\stack\low\platform\S3C2410\timer\include;..\..\stack\low\platform\S3C2410\uart\include;..\..\stack\low\platform\S3C2410\efuse\include;..\..\stack\low\platform\S3C2410\dma\include;..\..\stack\low\platform\S3C2410\mailbox\include;..\..\stack\low\platform\S3C2410\power_control\include;..\..\stack\low\platform\S3C2410\spi\include;..\..\stack\low\platform\S3C2410\new_io\include;..\..\stack\low\platform\S3C2410\scoreboard\include;..\..\stack\low\platform\S3C2410\system_on\include;..\..\stack\low\platform\S3C2410\i2c\include;..\..\stack\upper\inc;..\..\stack\upper\src\bt\btcore;..\..\stack\upper\src\bt\blueapi
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\BB3.sct
  link misc: --diag_suppress=L6314 --symdefs=..\symboltable.lib --datacompressor off
  group CMSIS
    ../../platform/cmsis/rtl876x/src/: system_rtl8763.c
    ../../platform/cmsis/rtl876x/src/arm/: startup_rtl8763.s
  group platform
    ../../platform/src/: main_full.c pingpong_buffer.c rtl_delay.c trace.c
  group os
    ../../os/freertos/src/: list.c queue.c tasks.c timers.c
    ../../os/freertos/src/portable/Keil/ARM_CM4F/: port.c
    ../../os/freertos/src/portable/MemMang/: heap.c
  group peripheral
    ../../peripheral/src/: rtl876x_uart.c rtl876x_gdma.c
  group app
    ../../apps/test/test_cm4_dsp/: cm4_dsp_test.c
    ../../apps/test/test_cm4_speed/: cm4_speed_test.c
    ../../apps/test/test_freertos/: freertos_test.c
    ../../apps/test/test_gdma_fw_sim/: gdma_fw_sim_test.c
  group patch
    ../../patch/src/: patch_framework.c patch_iodriver.c patch_lowerstack.c patch_upperstack.c
  group low_stack
    ../../stack/low/app/mint_os/: main.c
    ../../stack/low/btcontroller/core/auth/: bz_auth.c bz_auth_hci.c bz_auth_hci_2_1.c bz_auth_internal.c bz_auth_internal_2_1.c bz_auth_lkdb.c bz_auth_lmp.c bz_auth_lmp_2_1.c bz_auth_mlk.c bz_auth_top_stt.c
    ../../stack/low/btcontroller/core/baseband/: bb_driver.c bb_driver_3_0.c bb_driver_4_1.c bzdma.c g711.c
    ../../stack/low/btcontroller/core/bt_3dd/: bt_3dd.c
    ../../stack/low/btcontroller/core/hci/: bt_fw_acl_q.c bt_fw_hci.c bt_fw_hci_1_2_cmds.c bt_fw_hci_1_2_events.c bt_fw_hci_2_1_cmds.c bt_fw_hci_2_1_events.c bt_fw_hci_3_0_cmds.c bt_fw_hci_3_0_events.c bt_fw_hci_cmds.c bt_fw_hci_csa4_cmds.c bt_fw_hci_csa4_events.c bt_fw_hci_events.c bt_fw_hci_hcbb_info.c bt_fw_hci_secure_conn_cmds.c bt_fw_hci_secure_conn_events.c bt_fw_hci_tasks.c bt_fw_hci_utils.c
    ../../stack/low/btcontroller/core/hci_td/: hci_td.c hci_td_api.c hci_td_task.c
    ../../stack/low/btcontroller/core/lc/: lc.c lc_1_2_utils.c lc_2_1.c lc_isr.c lc_rf.c lc_scan.c lc_sync_links.c lc_task.c lc_utils.c
    ../../stack/low/btcontroller/core/ll/: le_hci_4_0.c le_ll.c le_ll_driver.c le_ll_general.c le_ll_isr.c le_llc.c
    ../../stack/low/btcontroller/core/lmp/: lmp.c lmp_1_2_pdu.c lmp_2_1.c lmp_3_0.c lmp_4_1.c lmp_afh.c lmp_ch_assessment.c lmp_datamgr.c lmp_edtm.c lmp_pdu.c lmp_pdu_q.c lmp_sco.c lmp_sync_links.c lmp_tasks.c lmp_utils.c
    ../../stack/low/btcontroller/core/mws/: mws.c mws_isr.c
    ../../stack/low/btcontroller/core/phy_init/: lc_phy_init.c
    ../../stack/low/btcontroller/core/secure_conn/: bt_secure_conn.c
    ../../stack/low/btcontroller/core/utils/: bz_fw_isoch.c bz_pf_isoch.c bz_utils.c
    ../../stack/low/btcontroller/core/: bt_fw_stack_init.c btc_2_1_init.c btc_3_0_init.c btc_init.c bz_bluetooth.c
    ../../stack/low/btcontroller/vendor/fm/: fm.c
    ../../stack/low/btcontroller/vendor/hci/: hci_vendor_cmds.c hci_vendor_events.c
    ../../stack/low/btcontroller/vendor/lmp/: lmp_vendor_datamgr.c
    ../../stack/low/btcontroller/vendor/plc/: plc.c
    ../../stack/low/btcontroller/vendor/pta/: pta.c pta_meter.c
    ../../stack/low/btcontroller/vendor/tv/: tv.c tv_poweron.c
    ../../stack/low/os/mint_os/src/: mint_os.c mint_os_buffer.c mint_os_queue.c mint_os_stack.c mint_os_task.c
    ../../stack/low/os_al/: bt_fw_os.c
    ../../stack/low/platform/S3C2410/4181/: hal_vectors.c mem.c print.c
    ../../stack/low/platform/S3C2410/baseband/: S3C2410_bt_power_ctrl.c
    ../../stack/low/platform/S3C2410/dma/: dma_usb.c h5.c
    ../../stack/low/platform/S3C2410/efuse/: efuse.c
    ../../stack/low/platform/S3C2410/gpio/: gpio.c
    ../../stack/low/platform/S3C2410/i2c/: i2c.c
    ../../stack/low/platform/S3C2410/mailbox/: mailbox.c
    ../../stack/low/platform/S3C2410/new_io/: new_io.c
    ../../stack/low/platform/S3C2410/otp/: otp.c
    ../../stack/low/platform/S3C2410/power_control/: power_control.c
    ../../stack/low/platform/S3C2410/scoreboard/: scoreboard.c
    ../../stack/low/platform/S3C2410/spi/: spi.c
    ../../stack/low/platform/S3C2410/system_on/: system_on.c
    ../../stack/low/platform/S3C2410/timer/: timer.c
    ../../stack/low/platform/S3C2410/uart/: uart.c UartPrintf.c
    ../../stack/low/platform/S3C2410/: S3C2410_task.c S3C2410_transport.c S3C2410_utils.c
    ../../stack/low/utils/crypto/: crypto.c crypto11.c ecdh.c mpal.c
    ../../stack/low/utils/logger/: lbm.c logger.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:DSP 1.4.6
