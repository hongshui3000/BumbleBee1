# Keil uVision project test_a2dp.uvproj, settings and files
target test_a2dp (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_peripheral +hex
  AfterMake: fromelf --bin -o output\trace "#L"
  c flags: Optim=1 uC99=1
  c define: TESTLEGACYDEMO
  c misc: --gnu
  c include: ..\..\..\inc\io;..\..\..\inc\app;..\..\..\inc\os\freertos;..\..\..\inc\platform\stollmann;..\..\..\src\stollmann\system\srp\startup;..\..\..\src\stollmann\system\srp\src\uart;..\..\..\src\stollmann\system\srp\src\target;..\..\..\src\stollmann\system\srp\src\hciapi;..\..\..\src\stollmann\system\srp\STM32F10x_StdPeriph_Driver\inc;..\..\..\src\stollmann\system\rtos\FreeRTOSV7.5.2\Source\portable;..\..\..\src\stollmann\system\rtos\FreeRTOSV7.5.2\Source\portable\RVDS\ARM_CM3;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\..\..\..\platform\inc;..\..\..\..\profile\gap\common;..\..\..\..\profile\gap\legacy;..\..\..\..\profile\legacy;..\..\..\..\os\osif\inc;..\..\..\..\stack\upper\inc;..\..\..\..\apps\test\test_a2dp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT5: ROM 0x8002000 size 0x7e000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\srp.sct
  group Startup
    ../../../src/stollmann/system/srp/startup/: main_freertos.c system_stm32f10x.c
    ../../../src/stollmann/system/srp/startup/keil/: stm32f10x_freertos.s
  group STM3210x_StdPeriph_driver
    ../../../src/stollmann/system/srp/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../../../src/stollmann/system/rtos/FreeRTOSV7.5.2/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../src/stollmann/system/rtos/FreeRTOSV7.5.2/Source/portable/MemMang/: heap_4.c
    ../../../src/stollmann/system/rtos/FreeRTOSV7.5.2/Source/portable/RVDS/ARM_CM3/: port.c
  group osif
    ../../../../os/osif/freertos/: osif_freertos.c
  group lib
    ../../../lib/stollmann/: btstack.lib
  group target
    ../../../src/stollmann/system/srp/src/target/: hw_srp_freertos.c
  group comuart
    ../../../src/stollmann/system/srp/src/uart/: comuart.c
  group hciapi
    ../../../src/stollmann/system/srp/src/hciapi/: hciapi_csr.c hciapitask_FreeRTOS.c
  group gap
    ../../../../profile/gap/common/: gap_common.c gapbond_common.c
    ../../../../profile/gap/legacy/: gapbond_legacy.c legacy.c mpa.c
  group application
    ../../../../apps/test/test_a2dp/: a2dp_demo.c app_queue.c application.c main.c my_stdio.c test_a2dp_application.c
  group profile
    ../../../../profile/legacy/: a2dp.c avdtp.c dip.c sbcdec.c sbcenc.c
  group port
    ../../../src/stollmann/system/port/: stfreertos.c
